# dont build libcanberra
PACKAGECONFIG = ""
