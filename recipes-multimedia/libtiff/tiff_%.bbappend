PACKAGECONFIG:append:class-target = " webp zstd"
