PACKAGECONFIG:append = " pulseaudio"

