PACKAGECONFIG:append = " x264 dvdread"

