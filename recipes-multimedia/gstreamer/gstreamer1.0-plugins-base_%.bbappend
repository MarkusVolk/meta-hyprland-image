PACKAGECONFIG:append = " opus gbm"
