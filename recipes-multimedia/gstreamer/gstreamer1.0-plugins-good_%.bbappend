PACKAGECONFIG:append = " gtk vpx"

