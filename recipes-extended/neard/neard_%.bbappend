# Remove recommendation for wpa-supplicant
RRECOMMENDS:${PN} = ""
