PACKAGECONFIG:append = " libusb libdecor pipewire"
PACKAGECONFIG:append:aarch64 = " arm-neon"
