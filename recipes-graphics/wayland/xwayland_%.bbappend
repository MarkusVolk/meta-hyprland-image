PACKAGECONFIG:append = " dri3"
