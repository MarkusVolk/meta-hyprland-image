# use udev instead of mknod
PACKAGECONFIG:append:class-target = " udev"

