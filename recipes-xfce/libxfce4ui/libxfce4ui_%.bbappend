do_install:append() {
	rm -rf ${D}${datadir}/applications
}
