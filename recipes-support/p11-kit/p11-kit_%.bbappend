PACKAGECONFIG = "trust-paths"

BBCLASSEXTEND = "native nativesdk"

