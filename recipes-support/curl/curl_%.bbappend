PACKAGECONFIG:append:class-target = " krb5 brotli nghttp2 zstd"
