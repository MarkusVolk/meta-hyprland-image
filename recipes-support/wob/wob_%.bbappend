PACKAGECONFIG:append = " seccomp"

