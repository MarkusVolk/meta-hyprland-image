PACKAGECONFIG:append = " bluez eds ofono telepathy"

