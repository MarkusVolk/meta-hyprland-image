PACKAGECONFIG:append:class-target = " cups colord"
